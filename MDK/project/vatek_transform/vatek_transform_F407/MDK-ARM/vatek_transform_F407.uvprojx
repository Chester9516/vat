# Keil uVision project vatek_transform_F407.uvprojx, settings and files
target vatek_transform_F407 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: vatek_transform_F407 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,VATEK_A3,RF_R2_VIA_VATEK,DEMOD_AVL68XX,TUNER_MXL608,VATEK_SAMPLE,SERVICE_TRANSFORM,DEBUG
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\..\..\..\inc;..\..\..\..\main\inc;..\..\..\..\peripheral\inc;..\..\..\..\sample\inc;..\..\..\..\system\inc;..\..\..\..\tool\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group vatekSDK/main
    ../../../../main/src/service/: vatek_transform.c
    ../../../../main/src/: vatek_hms.c vatek_modulator.c vatek_psispec_rule.c vatek_psitable.c vatek_tsmux.c vatek_tsp.c vatek_psispec_default.c
  group vatekSDK/peripheral
    ../../../../peripheral/src/tuner/MxL608/: MxL608_Main.c MxL608_OEM_Drv.c MxL608_TunerApi.c MxL608_TunerCfg.c MxL608_TunerSpurTable.c
    ../../../../peripheral/src/tuner/: tuner_MxL608.c vatek_tuner.c
    ../../../../peripheral/src/rf/: rf_r2_via_vatek.c vatek_rf.c
    ../../../../peripheral/src/demod/AVL68XX/: AVL_Demod_CommonAPI.c AVL_Demod_CommonInternal.c AVL_Demod_Config.c AVL_Demod_DVBC.c AVL_Demod_DVBSx.c AVL_Demod_DVBTx.c AVL_Demod_ISDBT.c user_defined_function.c
    ../../../../peripheral/src/demod/: demod_AVL68XX.c vatek_demod.c
  group vatekSDK/system
    ../../../../system/src/: vatek_porting_gpio.c vatek_porting_i2c.c vatek_porting_system.c vatek_porting_uart.c vatek_system.c
  group vatekSDK/sample
    ../../../../sample/src/: vatek_sample_transform.c
  group Application/User
    ../Src/: main.c gpio.c i2c.c rtc.c spi.c usart.c usb_device.c usbd_conf.c usbd_desc.c usbd_custom_hid_if.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Src/: usbd_customhid.c
software components: CMSIS:CORE 4.3.0
