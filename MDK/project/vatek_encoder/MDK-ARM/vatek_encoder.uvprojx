# Keil uVision project vatek_encoder.uvprojx, settings and files
target vatek_encoder (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F401VCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: vatek_encoder +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xC,VATEK_V1,PHY_H1,VATEK_A3,RF_R2_VIA_VATEK,SERVICE_TRANSFORM,SERVICE_ENCODER,DEBUG
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\..\..\inc;..\..\..\main\inc;..\..\..\peripheral\inc;..\..\..\sample\inc;..\..\..\system\inc;..\..\..\tool\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f401xc.s
  group Application/User
    ../Src/: main.c gpio.c i2c.c rtc.c spi.c usart.c usb_device.c usbd_conf.c usbd_desc.c usbd_custom_hid_if.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Src/: usbd_customhid.c
  group VAT_Main
    ../../../main/src/service/: vatek_broadcast_v1.c vatek_transform.c
    ../../../main/src/: vatek_encoder.c vatek_encoder_v1.c vatek_tsmux_v1.c vatek_userdata_v1.c vatek_hms.c vatek_modulator.c vatek_psitable.c vatek_tsp.c vatek_tsmux.c vatek_userdata.c vatek_capture.c vatek_enum.c vatek_psispec_rule.c vatek_psispec_default.c
  group VAT_System
    ../../../system/src/: vatek_porting_gpio.c vatek_porting_i2c.c vatek_porting_system.c vatek_porting_uart.c vatek_system.c
  group VAT_Peripheral
    ../../../peripheral/src/phy/: phy_h1.c vatek_phy.c tool_hdmi.c
    ../../../peripheral/src/rf/: rf_r2_via_vatek.c vatek_rf.c
  group VAT_Sample
    ../../../sample/src/: vatek_sample_encoder_via_h1.c vatek_sample_modulator.c
software components: CMSIS:CORE 4.3.0
